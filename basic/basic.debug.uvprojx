# Keil uVision project basic.debug.uvprojx, settings and files
target debug (6180000::V6.18::ARMCLANG)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.2.0
  cpu: IRAM(0x00000000,0x00080000) IRAM2(0x01000000,0x00200000) XRAM(0x20000000,0x00020000) XRAM2(0x20020000,0x00020000) XRAM3(0x20040000,0x00020000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: basic
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=6 wLevel=3
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x20020000 size 0x20000
  memory RVCT8: RAM 0x20040000 size 0x20000
  memory RVCT9: RAM 0x0 size 0x80000
  memory RVCT10: RAM 0x1000000 size 0x200000
  scatter file: ./RTE/Device/SSE-300-MPS3/fvp_sse300_mps3_s.sct
  link misc: --diag_suppress 6439,6314
  group Source
    ./: main.c retarget_stdio.c README.md
    ./RTE/Device/SSE-300-MPS3/: fvp_sse300_mps3_s.sct
software components: CMSIS Driver:USART 1.0.0, CMSIS:CORE 5.5.0, Device:Definition 1.1.0, Device:Startup 1.1.0, Native Driver:UART 1.0.0, Test:Unity 2.5.0, Compiler:I/O:STDOUT 1.2.0
